# Keil uVision project Blink.uvprojx, settings and files
target Blynk (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blink +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;.\qpc\platform\inc;.\qpc\port\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group scr
    ./src/: main.c board_STM32F407VET6.c blink.c
  group inc
    ./inc/: board_STM32F407VET6.h blink.h
  group qpc\platform\inc
    ./qpc/platform/inc/: qassert.h qep.h qequeue.h qf.h qf_pkg.h qmpool.h qpc.h qpset.h qs_dummy.h qxk.h qxk_pkg.h qxthread.h stdint_c.h
  group qpc\port\src
    ./qpc/port/src/: qxk_port.c
  group qpc\platform\src
    ./qpc/platform/src/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group qpc\port\inc
    ./qpc/port/inc/: qep_port.h qf_port.h qxk_port.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
